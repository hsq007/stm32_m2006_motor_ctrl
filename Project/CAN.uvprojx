# Keil uVision project CAN.uvprojx, settings and files
target e_rob (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIM_IT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\File\User;..\File\BSP;..\STM32_Lib\FWLib;..\STM32_Lib\CMSIS;..\STM32_Lib\CMSIS\Startup;..\File\API
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../File/User/: main.c motor_ctrl.c tf_2rd.c freq_scan.c pid.c erob_drv.c c610_drv.c hsq_math.c stm32f10x_it.c integrator.c
  group BSP
    ../File/BSP/: bsp_init.c can.c usart.c timer.c rtt.c SEGGER_RTT.c
  group CMSIS
    ../STM32_Lib/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../STM32_Lib/CMSIS/Startup/: startup_stm32f10x_md.s
  group FWLib
    ../STM32_Lib/FWLib/: stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h misc.c misc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_can.c stm32f10x_can.h stm32f10x_usart.c
